include ic4-gentl-driver.inc

RDEPENDS:${PN} = "util-linux-libuuid"
