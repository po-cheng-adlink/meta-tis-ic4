PACKAGECONFIG:remove = "ffmpeg"
